Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-08-25T11:37:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 25 11:37:51 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{128F8302-3A9A-4A3F-B8FD-6D7F5C76B64F}\ifc * Database version: 5507 * Database creation date: Wed Aug 25 11:37:50 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 25 11:37:50 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 25 11:37:50 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 25193681_USA_11791610_HR1936-3G_EDST-CLST, 11791610_USA_HR1936-3G_EDST-CLST:25193681_USA_11791610_HR1936-3G_EDST-CLST:211690
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Cast, z_Miele_Design_OBSW, z_Miele_Connection_Gas, z_Miele_Connection_Electric, z_Miele_Connection_Water_IN, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 25193681_USA_11791610_HR1936-3G_EDST-CLST
